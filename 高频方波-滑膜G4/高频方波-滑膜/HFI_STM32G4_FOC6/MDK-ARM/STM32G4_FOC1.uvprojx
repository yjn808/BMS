# Keil uVision project STM32G4_FOC1.uvprojx, settings and files
target STM32G4_FOC1 (6160000::V6.16::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G4_FOC1 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,ARM_MATH_CM4,SIMULINK_USE_ARM_MATH
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../SYSTEM/delay;../SYSTEM/sys;../SYSTEM/VOFA;../SYSTEM/my_usart;../APP/OLED;../SYSTEM/low_tesk;../FOC/foc_algorithm_ert_rtw;../FOC/speed_pid_ert_rtw;../FOC/IIR_LPF;../FOC/FOC_Control;../FOC/HFI_Square;../FOC/SMO_PLL_Observer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group FOC
    ../FOC/speed_pid_ert_rtw/: speed_pid.c
    ../FOC/foc_algorithm_ert_rtw/: foc_algorithm.c
    ../FOC/FOC_Control/: Foc_Control.c
    ../FOC/IIR_LPF/: IIR_LPF_wrapper.c
    ../FOC/HFI_Square/: hfi_square_wave.c
    ../FOC/SMO_PLL_Observer/: SMO_PLL.c
  group sys
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/VOFA/: vofa.c
    ../SYSTEM/my_usart/: my_usart.c
  group OLED
    ../APP/OLED/: IIC_OLED.c OLED_I2C.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
